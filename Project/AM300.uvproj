# Keil uVision project AM300.uvproj, settings and files
target ble_app_simple_server (ARM-ADS)
  device: HS6621C HunterSun
  cpu: CLOCK(64000000) CPUTYPE("Cortex-M4")
  output: AM300
  AfterMake: fromelf.exe --bin --output "$L..\@L.bin" "#L"
  AfterMake: fromelf.exe -c --output "$L..\@L.dis" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CONFIG_LOG_OUTPUT
  c misc: --c99 --via=.\lib\armcc.via
  c include: .\coroutine;.\lib;.\app;.\hardware\sys;.\hardware\cmsis;.\hardware\cfg;.\hardware\peripheral;.\hardware\rw_port;.\hardware\mbr;.\stack\ip\ahi\api;.\stack\ip\hci\api;.\stack\ip\sch\api;.\stack\ip\em\api;.\stack\modules\aes\api;.\stack\modules\common\api;.\stack\modules\dbg\api;.\stack\modules\display\api;.\stack\modules\ecc_p256\api;.\stack\modules\h4tl\api;.\stack\modules\ke\api;.\stack\modules\nvds\api;.\stack\modules\rf\api;.\stack\modules\rwip\api;.\stack\modules\rwip\src;.\stack\plf\hs6621\arch;.\stack\plf\hs6621\reg;.\stack\ip\ble\hl\api;.\stack\ip\ble\hl\inc;.\stack\ip\ble\hl\src\rwble_hl;.\stack\ip\ble\ll\api;.\stack\ip\ble\ll\src;.\stack\ip\ble\mesh\api;.\stack\ip\ble\mesh\inc;.\stack\ip\ble\mesh\inc_al;.\stack\ip\ble\mesh\src\common\inc;.\stack\ip\ble\mesh\src\inc;.\stack\ip\ble\mesh\src\models;.\stack\ip\ble\mesh\src\models\inc;.\stack\ip\ble\mesh\src\models\src;.\stack\ip\ble\mesh\src\prf;.\stack\ip\ble\mesh\src\prf\inc;.\stack\ip\ble\profiles\anp;.\stack\ip\ble\profiles\bas;.\stack\ip\ble\profiles\bcs;.\stack\ip\ble\profiles\blp;.\stack\ip\ble\profiles\cpp;.\stack\ip\ble\profiles\cscp;.\stack\ip\ble\profiles\dis;.\stack\ip\ble\profiles\find;.\stack\ip\ble\profiles\glp;.\stack\ip\ble\profiles\hogp;.\stack\ip\ble\profiles\hrp;.\stack\ip\ble\profiles\htp;.\stack\ip\ble\profiles\lan;.\stack\ip\ble\profiles\pasp;.\stack\ip\ble\profiles\prox;.\stack\ip\ble\profiles\rscp;.\stack\ip\ble\profiles\scpp;.\stack\ip\ble\profiles\tip;.\stack\ip\ble\profiles\uds;.\stack\ip\ble\profiles\wscp;.\stack\ip\ble\profiles\anp\anpc\api;.\stack\ip\ble\profiles\anp\anps\api;.\stack\ip\ble\profiles\bas\basc\api;.\stack\ip\ble\profiles\bas\bass\api;.\stack\ip\ble\profiles\bcs\bcsc\api;.\stack\ip\ble\profiles\bcs\bcss\api;.\stack\ip\ble\profiles\blp\blpc\api;.\stack\ip\ble\profiles\blp\blps\api;.\stack\ip\ble\profiles\cpp\cppc\api;.\stack\ip\ble\profiles\cpp\cpps\api;.\stack\ip\ble\profiles\cscp\cscpc\api;.\stack\ip\ble\profiles\cscp\cscps\api;.\stack\ip\ble\profiles\dis\disc\api;.\stack\ip\ble\profiles\dis\diss\api;.\stack\ip\ble\profiles\find\findl\api;.\stack\ip\ble\profiles\find\findt\api;.\stack\ip\ble\profiles\glp\glpc\api;.\stack\ip\ble\profiles\glp\glps\api;.\stack\ip\ble\profiles\hogp\hogpbh\api;.\stack\ip\ble\profiles\hogp\hogpd\api;.\stack\ip\ble\profiles\hogp\hogprh\api;.\stack\ip\ble\profiles\hrp\hrpc\api;.\stack\ip\ble\profiles\hrp\hrps\api;.\stack\ip\ble\profiles\htp\htpc\api;.\stack\ip\ble\profiles\htp\htpt\api;.\stack\ip\ble\profiles\lan\lanc\api;.\stack\ip\ble\profiles\lan\lans\api;.\stack\ip\ble\profiles\pasp\paspc\api;.\stack\ip\ble\profiles\pasp\pasps\api;.\stack\ip\ble\profiles\prox\proxm\api;.\stack\ip\ble\profiles\prox\proxr\api;.\stack\ip\ble\profiles\rscp\rscpc\api;.\stack\ip\ble\profiles\rscp\rscps\api;.\stack\ip\ble\profiles\scpp\scppc\api;.\stack\ip\ble\profiles\scpp\scpps\api;.\stack\ip\ble\profiles\tip\tipc\api;.\stack\ip\ble\profiles\tip\tips\api;.\stack\ip\ble\profiles\uds\udsc\api;.\stack\ip\ble\profiles\uds\udss\api;.\stack\ip\ble\profiles\wscp\wscc\api;.\stack\ip\ble\profiles\wscp\wscs\api;.\stack\ip\ble\profiles\tspp\tspps\api;.\stack\ip\ble\profiles\tspp\tsppc\api;.\stack\plf\hs6621\bb;.\stack\plf\hs6621\sc;.\stack\ip\ble\profiles\simple_server\api;.\stack\ip\ble\profiles\simple_server\src;.\stack\ip\ble\profiles\dis\diss\src;.\device;.\hardware\cmsis
  library: MicroLIB
  scatter file: .\lib\scatter_hs6621_flash.sct
  link misc: --via=.\lib\armlink.via
  group startup
    ./lib/: startup_hs6621_flash.s
  group main
    ./app/: main.c protocol.c crc8.c handler.c emg_wave.c stim_control.c algorithm.c fifter.c
    ./hardware/peripheral/: retarget.c
  group app
    ./app/: app.c app_adv.c app_task.c app_sec.c app_simple_server.c app_dis.c
  group profile
    ./stack/ip/ble/profiles/simple_server/src/: simple_server.c simple_server_task.c
    ./stack/ip/ble/profiles/dis/diss/src/: diss.c diss_task.c
  group stack
    ./stack/plf/hs6621/rwip/: rwmem.c
  group hardware
    ./device/: adc_ex.c bsp_adc.c bsp_battery.c bsp_gpio.c bsp_iic.c bsp_key.c bsp_spi.c bsp_systick.c bsp_usart.c bsp_timer.c
